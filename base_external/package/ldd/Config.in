## base_external/package/ldd/Config.in
```kconfig
config BR2_PACKAGE_LDD
    bool "ldd"
    help
      Build and install LDD3 out-of-tree kernel modules:
      misc-modules and scull.
```
